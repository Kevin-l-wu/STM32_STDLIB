# Keil uVision project SPI_FLASH.uvprojx, settings and files
target STM32_MINI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI_FLASH +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_STM3210B_EVAL
  c include: ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\SPI_FLASH;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Test\SPI;..\..\..\..\Test\Systick;..\..\..\..\Test\EXTI;..\..\..\..\Test\RCC;..\..\..\..\Test\TIM;..\..\..\..\Test\IWDG;..\..\..\..\Test\WWDG;..\..\..\..\Test\USART;..\..\..\..\Test\UTILITY;..\..\..\..\Test\I2C;..\..\..\..\Test\DMA;..\..\..\..\Test\ADC;..\..\..\..\Test\SDIO;..\..\..\..\FATFS;..\..\..\..\Test\KEY
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group USR
    ./: main.c stm32f10x_it.c system_stm32f10x.c LogDebug.c
  group STM32_STDLIB
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group EVAL
    ../../../../Utilities/STM32_EVAL/Common/: stm32_eval_spi_flash.c stm32_eval_i2c_ee.c stm32_eval_sdio_sd.c
    ../../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval.c
  group STM32_BSP
    ../../../../Test/SPI/: TestSpiFlash.c
    ../../../../Test/Systick/: BspSystick.c
    ../../../../Test/EXTI/: BspExti.c
    ../../../../Test/RCC/: BspRcc.c
    ../../../../Test/TIM/: BspTimer.c BspTimerBase.c BspTimerPwm.c BspTimerCapture.c BspTimer7Pwm.c BspTimer6Steps.c BspTimerOcToggle.c
    ../../../../Test/IWDG/: BspIwdg.c
    ../../../../Test/WWDG/: BspWwdg.c
    ../../../../Test/USART/: BspUsartPolling.c BspUsartDmaPolling.c BspUsartDmaInterrupt.c
    ../../../../Test/UTILITY/: BspUtility.c
    ../../../../Test/I2C/: BspI2cEeprom.c
    ../../../../Test/DMA/: BspDmaMtom.c
    ../../../../Test/ADC/: BspAdcSingle.c BspAdcDma.c BspAdcCont.c
    ../../../../Test/SDIO/: BspSdio.c
    ../../../../Test/KEY/: BspKey.c
  group FATFS
    ../../../../FATFS/: diskio.c ff.c
    ../../../../FATFS/option/: cc936.c
