# Keil uVision project I2C_E2PROM.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: I2C_E2PROM +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_STM3210C_EVAL
  c include: ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\EEPROM;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USR
    ./: main.c stm32f10x_it.c system_stm32f10x.c LogDebug.c
  group STM32_STDLIB
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c
  group CORE
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group EVAL
    ../../../../Utilities/STM32_EVAL/Common/: stm32_eval_i2c_ee.c
    ../../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval.c
